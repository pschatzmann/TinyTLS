/**
 * @file aes.h
 * AES block cipher (FIPS 197), encryption direction only. GCM and TLS 1.3 need
 * only the forward cipher.
 */
#pragma once

#include <string.h>
#include "config.h"

namespace tinytls {

namespace detail {

/** AES forward S-box (FIPS 197). */
static const uint8_t aes_sbox[256] = {
      0x63, 0x7c, 0x77, 0x7b, 0xf2, 0x6b, 0x6f, 0xc5, 0x30, 0x01, 0x67, 0x2b, 0xfe, 0xd7, 0xab,
      0x76, 0xca, 0x82, 0xc9, 0x7d, 0xfa, 0x59, 0x47, 0xf0, 0xad, 0xd4, 0xa2, 0xaf, 0x9c, 0xa4,
      0x72, 0xc0, 0xb7, 0xfd, 0x93, 0x26, 0x36, 0x3f, 0xf7, 0xcc, 0x34, 0xa5, 0xe5, 0xf1, 0x71,
      0xd8, 0x31, 0x15, 0x04, 0xc7, 0x23, 0xc3, 0x18, 0x96, 0x05, 0x9a, 0x07, 0x12, 0x80, 0xe2,
      0xeb, 0x27, 0xb2, 0x75, 0x09, 0x83, 0x2c, 0x1a, 0x1b, 0x6e, 0x5a, 0xa0, 0x52, 0x3b, 0xd6,
      0xb3, 0x29, 0xe3, 0x2f, 0x84, 0x53, 0xd1, 0x00, 0xed, 0x20, 0xfc, 0xb1, 0x5b, 0x6a, 0xcb,
      0xbe, 0x39, 0x4a, 0x4c, 0x58, 0xcf, 0xd0, 0xef, 0xaa, 0xfb, 0x43, 0x4d, 0x33, 0x85, 0x45,
      0xf9, 0x02, 0x7f, 0x50, 0x3c, 0x9f, 0xa8, 0x51, 0xa3, 0x40, 0x8f, 0x92, 0x9d, 0x38, 0xf5,
      0xbc, 0xb6, 0xda, 0x21, 0x10, 0xff, 0xf3, 0xd2, 0xcd, 0x0c, 0x13, 0xec, 0x5f, 0x97, 0x44,
      0x17, 0xc4, 0xa7, 0x7e, 0x3d, 0x64, 0x5d, 0x19, 0x73, 0x60, 0x81, 0x4f, 0xdc, 0x22, 0x2a,
      0x90, 0x88, 0x46, 0xee, 0xb8, 0x14, 0xde, 0x5e, 0x0b, 0xdb, 0xe0, 0x32, 0x3a, 0x0a, 0x49,
      0x06, 0x24, 0x5c, 0xc2, 0xd3, 0xac, 0x62, 0x91, 0x95, 0xe4, 0x79, 0xe7, 0xc8, 0x37, 0x6d,
      0x8d, 0xd5, 0x4e, 0xa9, 0x6c, 0x56, 0xf4, 0xea, 0x65, 0x7a, 0xae, 0x08, 0xba, 0x78, 0x25,
      0x2e, 0x1c, 0xa6, 0xb4, 0xc6, 0xe8, 0xdd, 0x74, 0x1f, 0x4b, 0xbd, 0x8b, 0x8a, 0x70, 0x3e,
      0xb5, 0x66, 0x48, 0x03, 0xf6, 0x0e, 0x61, 0x35, 0x57, 0xb9, 0x86, 0xc1, 0x1d, 0x9e, 0xe1,
      0xf8, 0x98, 0x11, 0x69, 0xd9, 0x8e, 0x94, 0x9b, 0x1e, 0x87, 0xe9, 0xce, 0x55, 0x28, 0xdf,
      0x8c, 0xa1, 0x89, 0x0d, 0xbf, 0xe6, 0x42, 0x68, 0x41, 0x99, 0x2d, 0x0f, 0xb0, 0x54, 0xbb,
      0x16};

/** AES key-schedule round constants. */
static const uint8_t aes_rcon[10] = {0x01, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x1b, 0x36};

}  // namespace detail

/**
 * AES block cipher (FIPS 197), encryption direction only.
 *
 * Supports 128-bit and 256-bit keys. Decryption is not implemented, because
 * GCM and TLS 1.3 only need the forward cipher. The key schedule is held in
 * the object and wiped on destruction.
 *
 * @note The S-box lookups are table based and are not constant-time with
 * respect to cache timing.
 */
class Aes {
 public:
  static constexpr size_t BlockSize = 16;  ///< Block size in bytes.

  /** Creates a cipher without a key. */
  Aes() : rounds_(0) { memset(rk_, 0, sizeof(rk_)); }

  ~Aes() { memset(rk_, 0, sizeof(rk_)); }

  /** Expands the key. keybits must be 128 or 256. */
  bool setKey(const uint8_t *key, unsigned keybits) {
    if (keybits != 128 && keybits != 256) return false;
    unsigned nk = keybits / 32;
    unsigned total = 4 * (nk + 7);
    rounds_ = (int)(nk + 6);
    for (unsigned i = 0; i < nk; i++) {
      rk_[i] = ((uint32_t)key[4 * i] << 24) | ((uint32_t)key[4 * i + 1] << 16) |
               ((uint32_t)key[4 * i + 2] << 8) | (uint32_t)key[4 * i + 3];
    }
    for (unsigned i = nk; i < total; i++) {
      uint32_t temp = rk_[i - 1];
      if (i % nk == 0) {
        temp = subWord((temp << 8) | (temp >> 24));
        temp ^= (uint32_t)detail::aes_rcon[i / nk - 1] << 24;
      } else if (nk > 6 && i % nk == 4) {
        temp = subWord(temp);
      }
      rk_[i] = rk_[i - nk] ^ temp;
    }
    return true;
  }

  /** Encrypts one block. in and out may alias. */
  void encryptBlock(const uint8_t in[16], uint8_t out[16]) const {
    uint8_t s[16], t[16];
    memcpy(s, in, 16);
    addRoundKey(s, rk_);
    for (int round = 1; round <= rounds_; round++) {
      for (int i = 0; i < 16; i++) s[i] = detail::aes_sbox[s[i]];
      for (int r = 0; r < 4; r++) {
        for (int c = 0; c < 4; c++) t[4 * c + r] = s[4 * ((c + r) % 4) + r];
      }
      if (round != rounds_) {
        for (int c = 0; c < 4; c++) {
          uint8_t a0 = t[4 * c], a1 = t[4 * c + 1], a2 = t[4 * c + 2], a3 = t[4 * c + 3];
          uint8_t all = a0 ^ a1 ^ a2 ^ a3;
          s[4 * c] = a0 ^ all ^ xtime(a0 ^ a1);
          s[4 * c + 1] = a1 ^ all ^ xtime(a1 ^ a2);
          s[4 * c + 2] = a2 ^ all ^ xtime(a2 ^ a3);
          s[4 * c + 3] = a3 ^ all ^ xtime(a3 ^ a0);
        }
      } else {
        memcpy(s, t, 16);
      }
      addRoundKey(s, rk_ + 4 * round);
    }
    memcpy(out, s, 16);
    memset(s, 0, sizeof(s));
    memset(t, 0, sizeof(t));
  }

 private:
  uint32_t subWord(uint32_t w) const {
    return ((uint32_t)detail::aes_sbox[(w >> 24) & 0xff] << 24) | ((uint32_t)detail::aes_sbox[(w >> 16) & 0xff] << 16) |
           ((uint32_t)detail::aes_sbox[(w >> 8) & 0xff] << 8) | (uint32_t)detail::aes_sbox[w & 0xff];
  }
  uint8_t xtime(uint8_t x) const { return (uint8_t)((x << 1) ^ ((x & 0x80) ? 0x1b : 0)); }
  void addRoundKey(uint8_t s[16], const uint32_t *rk) const {
    for (int c = 0; c < 4; c++) {
      for (int r = 0; r < 4; r++) s[4 * c + r] ^= (uint8_t)(rk[c] >> (24 - 8 * r));
    }
  }

  uint32_t rk_[60];
  int rounds_;
};

}  // namespace tinytls
