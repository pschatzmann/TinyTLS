// Mutation-based fuzz driver for the TinyTLS parsers and verifiers.
//
// Usage: tinytls_fuzz [iterations] [seed] [target]
//   target restricts the run to one target (see kTargets).
//
// Inputs start from the test PKI (PEM, DER, signatures and keys generated by
// make_test_pki.sh) and random bytes, then go through random mutations. The run
// is deterministic for a given seed. Build with -fsanitize=address,undefined
// (TINYTLS_SANITIZE=ON) to catch memory errors and undefined behaviour.
#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#include <fstream>
#include <iterator>
#include <random>
#include <string>
#include <vector>

#include "TinyTLS.h"
#include "fuzz_targets.h"

namespace {

typedef void (*Target)(const uint8_t *, size_t);

struct NamedTarget {
  const char *name;
  Target fn;
};

const NamedTarget kTargets[] = {
    {"certificate", fuzz::fuzzCertificate},  {"public_key", fuzz::fuzzPublicKey},
    {"store", fuzz::fuzzCertificateStore},   {"base64", fuzz::fuzzBase64},
    {"der_reader", fuzz::fuzzDerReader},     {"rsa", fuzz::fuzzRsa},
    {"ecdsa", fuzz::fuzzEcdsa},
    {"tls_handshake", fuzz::fuzzTlsHandshake},
};

std::vector<uint8_t> readFile(const std::string &path) {
  std::ifstream f(path, std::ios::binary);
  return std::vector<uint8_t>((std::istreambuf_iterator<char>(f)), {});
}

/** Seed inputs: the PKI files and their DER encodings. */
std::vector<std::vector<uint8_t>> loadSeeds() {
  std::vector<std::vector<uint8_t>> seeds;
#ifdef TINYTLS_TEST_PKI
  const char *files[] = {"ec_leaf.pem",    "ec_int.pem",       "ec_root.pem",       "rsa_leaf.pem",
                         "rsa_root.pem",   "ec_leaf_chain.pem", "ec_leaf_spki.der", "rsa_leaf_spki.der",
                         "ec_sig.der",     "rsa_pkcs1_sig.bin", "rsa_pss_sig.bin",  "msg.bin"};
  for (const char *name : files) {
    std::string path = std::string(TINYTLS_TEST_PKI) + "/" + name;
    std::vector<uint8_t> data = readFile(path);
    if (!data.empty()) seeds.push_back(data);
  }
  // DER encodings of the certificates in the PEM files.
  const char *pems[] = {"ec_leaf_chain.pem", "rsa_leaf.pem", "ec_root.pem"};
  for (const char *name : pems) {
    tinytls::CertificateStore store;
    std::vector<uint8_t> pem = readFile(std::string(TINYTLS_TEST_PKI) + "/" + name);
    if (store.addPem(pem.data(), pem.size()) != tinytls::Error::Ok) continue;
    for (size_t i = 0; i < store.size(); i++) {
      const tinytls::Certificate &c = store.at(i);
      seeds.push_back(std::vector<uint8_t>(c.der(), c.der() + c.derLength()));
    }
  }
#endif
  return seeds;
}

/** Applies n random mutations to the input. */
void mutate(std::vector<uint8_t> &in, std::mt19937 &rng, int n) {
  static const uint8_t kInteresting[] = {0x00, 0x01, 0x02, 0x7f, 0x80, 0xff, 0x30, 0x31,
                                         0x02, 0x04, 0x06, 0x17, 0x18, 0x82, 0x81, 0xa0, 0xa3};
  for (int k = 0; k < n; k++) {
    int op = (int)(rng() % 8);
    if (in.empty() || op == 6) {
      in.push_back((uint8_t)rng());
      continue;
    }
    size_t pos = rng() % in.size();
    switch (op) {
      case 0: in[pos] ^= (uint8_t)(1u << (rng() % 8)); break;                 // bit flip
      case 1: in[pos] = (uint8_t)rng(); break;                                 // random byte
      case 2: in[pos] = kInteresting[rng() % sizeof(kInteresting)]; break;     // DER-relevant byte
      case 3: in.insert(in.begin() + (long)pos, (uint8_t)rng()); break;        // insert
      case 4: in.erase(in.begin() + (long)pos); break;                         // delete
      case 5: in.resize(pos); break;                                           // truncate
      case 7: {                                                                // duplicate a chunk
        size_t len = 1 + rng() % 16;
        if (pos + len > in.size()) len = in.size() - pos;
        std::vector<uint8_t> chunk(in.begin() + (long)pos, in.begin() + (long)(pos + len));
        in.insert(in.begin() + (long)(rng() % in.size()), chunk.begin(), chunk.end());
        break;
      }
    }
  }
}

}  // namespace

int main(int argc, char **argv) {
  unsigned long iterations = argc > 1 ? strtoul(argv[1], nullptr, 10) : 20000;
  unsigned seed = argc > 2 ? (unsigned)strtoul(argv[2], nullptr, 10) : 1;
  std::mt19937 rng(seed);
  std::vector<std::vector<uint8_t>> seeds = loadSeeds();
  std::vector<const NamedTarget *> targets;
  for (const NamedTarget &t : kTargets) {
    if (argc <= 3 || std::string(argv[3]) == t.name) targets.push_back(&t);
  }
  if (targets.empty()) {
    fprintf(stderr, "unknown target: %s\n", argv[3]);
    return 2;
  }

  unsigned long runs = 0;
  for (unsigned long i = 0; i < iterations; i++) {
    const NamedTarget &target = *targets[i % targets.size()];
    std::vector<uint8_t> input;
    if (seeds.empty() || rng() % 8 == 0) {
      input.resize(rng() % 2048);  // random bytes
      for (auto &b : input) b = (uint8_t)rng();
    } else {
      input = seeds[rng() % seeds.size()];
    }
    mutate(input, rng, 1 + (int)(rng() % 8));
    target.fn(input.data(), input.size());
    runs++;
  }
  printf("fuzz: %lu inputs over %zu targets, seed %u, no failures\n", runs, targets.size(), seed);
  printf("fuzz: handshake flights reached: %lu, handshakes completed: %lu\n", fuzz::handshakeFlights(),
         fuzz::handshakeCompletions());
  return 0;
}
